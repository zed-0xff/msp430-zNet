# IAR project zHub.ewp, settings and files
configuration EZ430_CC1101 (MSP430, debug)
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 512
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: __BSP_EZ430; __RADIO_A1101R09; __RADIO_CERTIFICATION_FCC
  ICC430.newCCIncludePaths: ; ..\src\Framework\; ..\src\Library\
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.AUserIncludes: as above
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2274.xcl
  XLINK.XlinkStackSize: 1
configuration EZ430_CC110L (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: __BSP_EZ430; __RADIO_A110LR09; __RADIO_CERTIFICATION_FCC
configuration EZ430_CC2500 (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: __BSP_EZ430; __RADIO_A2500R24; __RADIO_CERTIFICATION_FCC
configuration LaunchPad_CC1101 (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 180
  ICC430.CCDefines: __BSP_LAUNCHPAD_AIRBOOSTERPACKLITE; __RADIO_A1101R09; __RADIO_CERTIFICATION_FCC
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
configuration LaunchPad_CC2500 (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 180
  ICC430.CCDefines: __BSP_LAUNCHPAD_AIRBOOSTERPACKLITE; __RADIO_A2500R24; __RADIO_CERTIFICATION_FCC
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
configuration LaunchPad_CC110L_ETSI (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 180
  ICC430.CCDefines: __BSP_LAUNCHPAD_AIRBOOSTERPACKLITE; __RADIO_A110LR09; __RADIO_CERTIFICATION_ETSI
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
configuration LaunchPad_CC110L_FCC (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 180
  ICC430.CCDefines: __BSP_LAUNCHPAD_AIRBOOSTERPACKLITE; __RADIO_A110LR09; __RADIO_CERTIFICATION_FCC
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  group AIRLibrary
    ../src/Library/IAR/: AIRRadioSettingETSI.r43 AIRRadioSettingFCC.r43
  group Application
    ../src/Application/: Application.c Application.h Callback.c Callback.h CommandInterface.c CommandInterface.h Definitions.h main.c Protocol.c Protocol.h RadioOperation.c RadioOperation.h
    ../../common/: z.h
  group Framework/BSP
    ../src/Framework/BSP/: Board.h BoardDrivers.h
  group Framework/BSP/Boards/EZ430
    ../src/Framework/BSP/Boards/EZ430/: EZ430.c EZ430.h EZ430Config.h EZ430Drivers.h
  group Framework/BSP/Boards/LaunchPad
    ../src/Framework/BSP/Boards/LaunchPad/: LaunchPad.c LaunchPad.h LaunchPadConfig.h LaunchPadDrivers.h
  group Framework/BSP/Boards/LaunchPad/AIRBoosterPackLite
    ../src/Framework/BSP/Boards/LaunchPad/AIRBoosterPackLite/: AIRBoosterPackLite.c AIRBoosterPackLite.h AIRBoosterPackLiteConfig.h AIRBoosterPackLiteDrivers.h
  group Framework/Drivers/ADC
    ../src/Framework/Drivers/ADC/: ADC.h
  group Framework/Drivers/Flash
    ../src/Framework/Drivers/Flash/: Flash.h
  group Framework/Drivers/LED
    ../src/Framework/Drivers/LED/: LED.h
  group Framework/Drivers/PushButton
    ../src/Framework/Drivers/PushButton/: PushButton.c PushButton.h
  group Framework/Drivers/Radio
    ../src/Framework/Drivers/Radio/: Radio.c Radio.h RadioStruct.h
  group Framework/Drivers/Radio/CCXXX
    ../src/Framework/Drivers/Radio/CCXXX/: CCXXXConfig.h
  group Framework/Drivers/Radio/CCXXX/Interface
    ../src/Framework/Drivers/Radio/CCXXX/Interface/: CC1101Interface.c CC1101Interface.h
  group Framework/Drivers/Radio/CCXXX/Model
    ../src/Framework/Drivers/Radio/CCXXX/Model/: CC1101.h CC110L.h CC2500.h
  group Framework/Drivers/Random
    ../src/Framework/Drivers/Random/: Random.h
  group Framework/Drivers/SPI
    ../src/Framework/Drivers/SPI/: SPI.h
  group Framework/Drivers/Timer
    ../src/Framework/Drivers/Timer/: SoftwareTimer.c SoftwareTimer.h SoftwareTimerStruct.h Timer.h
  group Framework/Drivers/UART
    ../src/Framework/Drivers/UART/: UART.h
  group Framework/Drivers/Watchdog
    ../src/Framework/Drivers/Watchdog/: Watchdog.h
  group Framework/HAL
    ../src/Framework/HAL/: HAL.h
  group Framework/HAL/Common
    Framework/HAL/Common/: CommonDefinitions.h
  group Framework/HAL/Common/DataManagement/CircularBuffer
    ../src/Framework/HAL/Common/DataManagement/CircularBuffer/: CircularBuffer.c CircularBuffer.h
  group Framework/HAL/Common/EventHanding
    ../src/Framework/HAL/Common/EventHandling/: EventHandling.c EventHandling.h
  group Framework/HAL/Common/RandomNumberGenerator
    ../src/Framework/HAL/Common/RandomNumberGenerator/: RandomNumberGenerator.h RandomNumberGenerator.s43
  group Framework/HAL/MSP430
    ../src/Framework/HAL/MSP430/: Config.h
  group Framework/HAL/MSP430/Model
    ../src/Framework/HAL/MSP430/Model/: F2274.h G2553.h
  group Framework/HAL/MSP430/Peripherals/Architecture/BasicClockModulePlus
    ../src/Framework/HAL/MSP430/Peripherals/Architecture/BasicClockModulePlus/: BasicClockModulePlus.h
  group Framework/HAL/MSP430/Peripherals/Architecture/FlashModule
    ../src/Framework/HAL/MSP430/Peripherals/Architecture/FlashModule/: FlashModule.c FlashModule.h
  group Framework/HAL/MSP430/Peripherals/Communication
    ../src/Framework/HAL/MSP430/Peripherals/Communication/: Communication.c Communication.h
  group Framework/HAL/MSP430/Peripherals/Communication/USCI
    ../src/Framework/HAL/MSP430/Peripherals/Communication/USCI/: USCI.c USCI.h
  group Framework/HAL/MSP430/Peripherals/DataConverter/ADC10
    ../src/Framework/HAL/MSP430/Peripherals/DataConverter/ADC10/: ADC10.c ADC10.h
  group Framework/HAL/MSP430/Peripherals/GPIO/DigitalIO
    ../src/Framework/HAL/MSP430/Peripherals/GPIO/DigitalIO/: DigitalIO.c DigitalIO.h
  group Framework/HAL/MSP430/Peripherals/Timer/TimerA
    ../src/Framework/HAL/MSP430/Peripherals/Timer/TimerA/: TimerA.c TimerA.h
  group Framework/HAL/MSP430/Peripherals/Timer/TimerB
    ../src/Framework/HAL/MSP430/Peripherals/Timer/TimerB/: TimerB.c TimerB.h
  group Framework/HAL/MSP430/Peripherals/Timer/WatchdogTimerPlus
    ../src/Framework/HAL/MSP430/Peripherals/Timer/WatchdogTimerPlus/: WatchdogTimerPlus.c WatchdogTimerPlus.h
